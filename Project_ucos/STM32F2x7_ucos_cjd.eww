<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM32F2x7_ucos_cjd.ewp</path>
  </project>
  <batchBuild/>
</workspace>


