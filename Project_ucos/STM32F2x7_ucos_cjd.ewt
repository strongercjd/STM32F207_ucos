<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\CM3\CoreSupport\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx\system_stm32f2xx.c</name>
    </file>
  </group>
  <group>
    <name>startup</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx\startup\iar\cstartup.c</name>
    </file>
  </group>
  <group>
    <name>STM32F2xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>uCOS-III</name>
    <group>
      <name>uC-CPU</name>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uC-CPU\ARM-Cortex-M3\IAR\cpu_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uC-CPU\ARM-Cortex-M3\IAR\cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uC-CPU\cpu_core.c</name>
      </file>
    </group>
    <group>
      <name>uC-LIB</name>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uC-LIB\lib_ascii.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uC-LIB\lib_math.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uC-LIB\lib_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uC-LIB\Ports\ARM-Cortex-M3\IAR\lib_mem_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uC-LIB\lib_str.c</name>
      </file>
    </group>
    <group>
      <name>uCOS-III</name>
      <group>
        <name>Ports</name>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_a.asm</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_c.c</name>
        </file>
      </group>
      <group>
        <name>Source</name>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_cfg_app.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_dbg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_flag.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_int.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_msg.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_mutex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_pend_multi.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_prio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_q.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_sem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_stat.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_task.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_tick.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_time.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_tmr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_type.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Third_Party\uCOS-III\uCOS-III\Source\os_var.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>UCOS_BSP</name>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_BSP\bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_BSP\bsp_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_BSP\bsp_ioe.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_BSP\bsp_lcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_BSP\bsp_os.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_BSP\bsp_ser.c</name>
      </file>
    </group>
    <group>
      <name>UCOS_CONFIG</name>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_CONFIG\cpu_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_CONFIG\includes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_CONFIG\os_app_hooks.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_CONFIG\os_app_hooks.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_CONFIG\os_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Third_Party\uCOS-III\UCOS_CONFIG\os_cfg_app.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\src\hard_bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\src\stm32f2xx_it.c</name>
    </file>
  </group>
</project>


